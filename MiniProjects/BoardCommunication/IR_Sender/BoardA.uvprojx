# Keil uVision project BoardA.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: BoardA
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=2
  c include: ./inc;..\common\inc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Files
    ./src/: main.c IR.c timers.c
    ../common/src/: delay.c LCD_4bit.c LEDs.c queue.c uart.c
  group Include Files
    ./inc/: user_defs.h IR.h timers.h
    ../common/inc/: delay.h LCD_4bit.h LEDs.h queue.h uart.h
software components: CMSIS:CORE 5.5.0, Device:Startup 2.5.0
