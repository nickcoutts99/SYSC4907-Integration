# Keil uVision project BasicUI.uvproj, settings and files
target KL25Z Flash (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: BasicUI
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c include: .\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
  group Startup
    ./: startup_MKL25Z4.s
    ./src/: system_MKL25Z4.c
  group source
    ./src/: LCD_4bit.c main.c LEDs.c timers.c delay.c ultrasonic.c ultrasonic_array.c queue.c
  group include
    ./inc/: delay.h LEDs.h timers.h ultrasonic.h ultrasonic_array.h queue.h
