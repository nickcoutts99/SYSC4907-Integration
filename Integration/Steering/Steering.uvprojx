# Keil uVision project Steering.uvprojx, settings and files
target Steering (6160000::V6.16::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Steering
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\inc;..\Common\inc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group src
    ./src/: main.c timers.c motor.c
    ../Common/src/: delay.c uart.c queue.c LEDs.c LCD_4bit.c
  group inc
    ./inc/: timers.h motor.h
    ../Common/inc/: delay.h uart.h GPIO_defs.h lcd_4bit.h LEDs.h queue.h
software components: CMSIS:CORE 5.5.0, Device:Startup 2.5.0
